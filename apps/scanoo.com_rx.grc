<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>gui_ref_level</value></param>
<param><key>value</key><value>-55</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>quad_decim</value></param>
<param><key>value</key><value>int(channel_samp_rate/quad_samp_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>squelch_mag</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>(10 * math.log(max(func_quad_avg_mag_sqrd,2),20))-15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>quad_samp_rate</value></param>
<param><key>value</key><value>audio_samp_rate*4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsk_deviation_hz</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq_step</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>samp_rate * 0.1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>combined_ch_bins</value></param>
<param><key>value</key><value>int(channel_samp_rate/bin_bw)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>value</key><value>-((samp_rate/2) * 1.25)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_samp_rate</value></param>
<param><key>value</key><value>48e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_decim</value></param>
<param><key>value</key><value>int(quad_samp_rate/audio_samp_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_click_freq_rounded</value></param>
<param><key>value</key><value>round(float(channel_click_freq) / ch_step_size, 0) * ch_step_size</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>left_edge_freq</value></param>
<param><key>value</key><value>center_freq-(samp_rate/2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bin_index</value></param>
<param><key>value</key><value>(channel_freq - left_edge_freq)/bin_bw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bin_bw</value></param>
<param><key>value</key><value>int(1e3)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_samp_rate</value></param>
<param><key>value</key><value>(quad_samp_rate*4)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gui_sizes</value></param>
<param><key>value</key><value>[1024,400]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_freq</value></param>
<param><key>value</key><value>channel_click_freq_rounded if ((channel_click_freq_rounded &lt; (center_freq + samp_rate/2)) and (channel_click_freq_rounded &gt; (center_freq - samp_rate/2))) else center_freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>int(samp_rate/bin_bw)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>20e6</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>combined_ch_bins</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>otw</key><value>sc16</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>sync</key><value>sync</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(center_freq, rf_freq=(center_freq + lo_offset),rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>gain0</key><value>15</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_stream_to_vector_decimator</key>
<param><key>id</key><value>blocks_stream_to_vector_decimator_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>vec_rate</key><value>30</value></param>
<param><key>vlen</key><value>1024</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>center_freq</value></param>
</block>
<block>
<key>wxgui_termsink</key>
<param><key>id</key><value>wxgui_termsink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>win_size</key><value>350,350</value></param>
<param><key>grid_pos</key><value>4,0,1,1</value></param>
</block>
<block>
<key>blocks_message_sink</key>
<param><key>id</key><value>blocks_message_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>dont_block</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>msglevel</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Message Level</value></param>
<param><key>value</key><value>1</value></param>
<param><key>choices</key><value>[-1, 0,1,2,3]</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>0,6,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>cfg_rf_gain</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>50</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>nb_controls,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>cfg_if_gain</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>50</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
<param><key>notebook</key><value>nb_controls,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>cfg_bb_gain</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>50</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>0,2,1,1</value></param>
<param><key>notebook</key><value>nb_controls,1</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>omega</key><value>sps</value></param>
<param><key>gain_omega</key><value>270e-6</value></param>
<param><key>mu</key><value>0.4</value></param>
<param><key>gain_mu</key><value>0.03</value></param>
<param><key>omega_relative_limit</key><value>100e-6</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>gain</key><value>audio_samp_rate/(2*math.pi*fsk_deviation_hz/8.0)</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_bb_gain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>bb_gain</value></param>
<param><key>writeback</key><value>bb_gain</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_if_gain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>if_gain</value></param>
<param><key>writeback</key><value>if_gain</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_rf_gain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>rf_gain</value></param>
<param><key>writeback</key><value>rf_gain</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_modulation</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>modulation</value></param>
<param><key>writeback</key><value>modulation</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>channel_samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>True</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>grid_pos</key><value>2,1,1,1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_NORM</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Click to Fine Tune</value></param>
<param><key>samp_rate</key><value>channel_samp_rate</value></param>
<param><key>baseband_freq</key><value>center_freq</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>2**11</value></param>
<param><key>fft_rate</key><value>2**3</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>750,1</value></param>
<param><key>grid_pos</key><value>1,0,1,2</value></param>
<param><key>notebook</key><value>nb_gfx,0</value></param>
<param><key>freqvar</key><value>channel_click_freq</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>func_center_freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>[127e6]</value></param>
<param><key>block_id</key><value>probe_center_freq</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>100</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>probe_center_freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_center_freq</value></param>
<param><key>value</key><value>int(100e6)</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>center_freq</value></param>
<param><key>writeback</key><value>center_freq</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_channel_click_freq</value></param>
<param><key>value</key><value>int(center_freq)</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>channel_click_freq</value></param>
<param><key>writeback</key><value>channel_click_freq</value></param>
</block>
<block>
<key>analog_probe_avg_mag_sqrd_x</key>
<param><key>id</key><value>probe_quad_avg_mag_sqrd</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>c</value></param>
<param><key>threshold</key><value>0</value></param>
<param><key>alpha</key><value>0.1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>func_quad_avg_mag_sqrd</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>30</value></param>
<param><key>block_id</key><value>probe_quad_avg_mag_sqrd</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>combined_ch_bins</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>window</key><value></value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>combined_ch_bins</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>quad_decim</value></param>
<param><key>taps</key><value>firdes.low_pass_2(1, channel_samp_rate, ch_width, ch_trans, 40, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>threshold</key><value>squelch_threshold</value></param>
<param><key>alpha</key><value>0.5</value></param>
<param><key>ramp</key><value>int(quad_samp_rate/8)</value></param>
<param><key>gate</key><value>True</value></param>
</block>
<block>
<key>analog_feedforward_agc_cc</key>
<param><key>id</key><value>analog_feedforward_agc_cc_0</value></param>
<param><key>num_samples</key><value>1024</value></param>
<param><key>reference</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>modulation_selector_out</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>input_index</key><value>modulation</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>analog_am_demod_cf</key>
<param><key>id</key><value>analog_am_demod_cf_0</value></param>
<param><key>chan_rate</key><value>quad_samp_rate</value></param>
<param><key>audio_decim</key><value>audio_decim</value></param>
<param><key>audio_pass</key><value>2500</value></param>
<param><key>audio_stop</key><value>2800</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1 if (int(modulation) == 1) else 0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1 if (int(modulation) == 2) else 0</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_0</value></param>
<param><key>audio_rate</key><value>int(audio_samp_rate)</value></param>
<param><key>quad_rate</key><value>int(quad_samp_rate)</value></param>
<param><key>tau</key><value>75e-6</value></param>
<param><key>max_dev</key><value>5e3</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>quad_rate</key><value>quad_samp_rate</value></param>
<param><key>audio_decimation</key><value>audio_decim</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1 if (int(modulation) == 0) else 0</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>modulation_selector_in</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>3</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>output_index</key><value>modulation</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_ch_width</value></param>
<param><key>value</key><value>int(6.25e3)</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>ch_width</value></param>
<param><key>writeback</key><value>ch_width</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_len</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>m</key><value>combined_ch_bins</value></param>
<param><key>n</key><value>fft_len</value></param>
<param><key>offset</key><value>int(bin_index-(float(combined_ch_bins)/2))</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fft_len</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value></value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>cfg_center_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>nb_controls,3</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>channel_click_freq</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>cfg_channel_click_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
<param><key>notebook</key><value>nb_controls,3</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>modulation</value></param>
<param><key>label</key><value>Modulation</value></param>
<param><key>value</key><value>cfg_modulation</value></param>
<param><key>choices</key><value>[0,1,2]</value></param>
<param><key>labels</key><value>["AM","NBFM","WBFM"]</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>nb_controls,2</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ch_width</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>min(cfg_ch_width,(quad_samp_rate*0.99))</value></param>
<param><key>min</key><value>int(1e3)</value></param>
<param><key>max</key><value>int(quad_samp_rate*0.99)</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>nb_controls,4</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb_gfx</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['Fine Tune FFT', 'Rough Tune FFT', 'Fine Tune Waterfall', 'Rough Tune Waterfall']</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_squelch_threshold</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>squelch_threshold</value></param>
<param><key>writeback</key><value>squelch_threshold</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_ch_trans</value></param>
<param><key>value</key><value>int(1e3)</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>ch_trans</value></param>
<param><key>writeback</key><value>ch_trans</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb_controls</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['squelch', 'gain', 'modulation','freq','bandwidth','volume']</value></param>
<param><key>grid_pos</key><value>2,0,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>volume</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>cfg_volume</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>nb_controls,5</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ch_trans</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>min(cfg_ch_trans,int(quad_samp_rate*0.99))</value></param>
<param><key>min</key><value>int(1e3)</value></param>
<param><key>max</key><value>int(quad_samp_rate*0.99)</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
<param><key>notebook</key><value>nb_controls,4</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_ch_step_size</value></param>
<param><key>value</key><value>6.25e3</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>ch_step_size</value></param>
<param><key>writeback</key><value>ch_step_size</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_volume</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>volume</value></param>
<param><key>writeback</key><value>volume</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>volume</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>squelch_threshold</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>cfg_squelch_threshold</value></param>
<param><key>min</key><value>-100</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>nb_controls,0</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>samp_rate</key><value>int(audio_samp_rate)</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Click to Fine Tune</value></param>
<param><key>samp_rate</key><value>channel_samp_rate</value></param>
<param><key>baseband_freq</key><value>channel_freq</value></param>
<param><key>y_per_div</key><value>5</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>20</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>2**10</value></param>
<param><key>fft_rate</key><value>2**5</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.1</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>gui_sizes</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>freqvar</key><value>channel_click_freq</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>ch_step_size</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>cfg_ch_step_size</value></param>
<param><key>choices</key><value>[1e3, 2.5e3, 5e3, 6.25e3, 8.33e3, 12.5e3, 25e3, 50e3,100e3, 200e3]</value></param>
<param><key>labels</key><value>["1e3", "2.5e3", "5e3", "6.25e3", "8.33e3", "12.5e3", "25e3", "50e3","100e3", "200e3"]</value></param>
<param><key>type</key><value>drop_down</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>0,2,1,1</value></param>
<param><key>notebook</key><value>nb_controls,3</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>otw</key><value>sc16</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.3</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(center_freq, rf_freq=(center_freq + lo_offset),rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>gain0</key><value>15</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>cc</value></param>
<param><key>length</key><value>2**9</value></param>
<param><key>long_form</key><value>False</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Fine Tune Waterfall</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>center_freq</value></param>
<param><key>dynamic_range</key><value>50</value></param>
<param><key>ref_level</key><value>gui_ref_level</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>2**10</value></param>
<param><key>fft_rate</key><value>2**3</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.25</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>gui_sizes</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>nb_gfx,2</value></param>
<param><key>freqvar</key><value>channel_click_freq</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Rough Tune Waterfall</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>center_freq</value></param>
<param><key>dynamic_range</key><value>50</value></param>
<param><key>ref_level</key><value>gui_ref_level</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>2**10</value></param>
<param><key>fft_rate</key><value>2**3</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.25</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>gui_sizes</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>nb_gfx,3</value></param>
<param><key>freqvar</key><value>center_freq</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1_0_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Fine Tune FFT</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>center_freq</value></param>
<param><key>y_per_div</key><value>5</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>gui_ref_level</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>2**10</value></param>
<param><key>fft_rate</key><value>2**3</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.1</value></param>
<param><key>win</key><value>window.hamming</value></param>
<param><key>win_size</key><value>gui_sizes</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>nb_gfx,0</value></param>
<param><key>freqvar</key><value>channel_click_freq</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Rough Tune FFT</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>center_freq</value></param>
<param><key>y_per_div</key><value>5</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>gui_ref_level</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>2**10</value></param>
<param><key>fft_rate</key><value>2**3</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.1</value></param>
<param><key>win</key><value>window.hamming</value></param>
<param><key>win_size</key><value>gui_sizes</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>nb_gfx,1</value></param>
<param><key>freqvar</key><value>center_freq</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_len</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value>hackrf=0</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>gain_mode0</key><value>0</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>if_gain0</key><value>if_gain</value></param>
<param><key>bb_gain0</key><value>bb_gain</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>scanoo_com_rx</value></param>
<param><key>author</key><value>Mike Jameson M0MIK</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>probe_center_freq</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_decimator_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_2</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>blocks_message_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_sink_0</source_block_id><sink_block_id>wxgui_termsink_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>fft_filter_xxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>probe_quad_avg_mag_sqrd</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>wxgui_fftsink2_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>wxgui_fftsink2_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>analog_feedforward_agc_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_feedforward_agc_cc_0</source_block_id><sink_block_id>modulation_selector_in</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>wxgui_fftsink2_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_1</source_block_id><sink_block_id>analog_am_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>analog_nbfm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modulation_selector_out</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_1_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>modulation_selector_out</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_0</source_block_id><sink_block_id>modulation_selector_out</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>modulation_selector_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modulation_selector_in</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modulation_selector_in</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modulation_selector_in</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>wxgui_fftsink2_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>wxgui_fftsink2_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>wxgui_fftsink2_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>wxgui_fftsink2_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
