<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>scanoo_com_rx</value></param>
<param><key>title</key><value>scanoo.com_rx</value></param>
<param><key>author</key><value>Mike Jameson M0MIK</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq_step</value></param>
<param><key>value</key><value>samp_rate*0.7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>int(func_center_freq[0]) if ((func_center_freq[0] &gt; 0) and (center_freq_hop_button)) else int(txt_center_freq)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_samp_rate</value></param>
<param><key>value</key><value>(quad_samp_rate*1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>click_center_freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>float(cfg_center_freq)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>func_probe_rate</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>quad_decim</value></param>
<param><key>value</key><value>int(channel_samp_rate/quad_samp_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_click_freq_rounded</value></param>
<param><key>value</key><value>(round(float(channel_click_freq) / ch_step_size, 0) * ch_step_size)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gui_average</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bin_index</value></param>
<param><key>value</key><value>max_bin_index if spectrum_sense_button else (float(channel_click_freq_rounded - left_edge_freq)/bin_bw)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>left_edge_freq</value></param>
<param><key>value</key><value>center_freq - (float(samp_rate)/2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_bin_index</value></param>
<param><key>value</key><value>int(fft_signal_level.index(max([i for j, i in enumerate(fft_signal_level) if (int(math.floor(float(j)/bin_floor)*bin_floor) not in blocked_bin_list )])))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>channel_click_freq_rounded if ((channel_click_freq_rounded &lt; ((txt_center_freq) + (float(samp_rate)/2))) or (channel_click_freq_rounded &gt; ((txt_center_freq) + (float(samp_rate)/2)))) else float(txt_center_freq)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gui_fft_size</value></param>
<param><key>value</key><value>2**10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>blocked_bin_list</value></param>
<param><key>value</key><value>[int(math.floor(float(((blocked_freq-(center_freq-(samp_rate/2)))/bin_bw))/bin_floor)*bin_floor) for blocked_freq in blocked_freq_list]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>blocked_freq_list</value></param>
<param><key>value</key><value>[int(blocked_freq) for blocked_freq in txt_blocked_freq_list.split()]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bin_bw</value></param>
<param><key>value</key><value>int(1e3)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gui_ref_level</value></param>
<param><key>value</key><value>-10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gui_sizes</value></param>
<param><key>value</key><value>[1250,500]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_decim</value></param>
<param><key>value</key><value>int(quad_samp_rate/audio_samp_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bin_floor</value></param>
<param><key>value</key><value>int(150e3/bin_bw)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_channel_freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>(round(float(int(left_edge_freq+(bin_bw*bin_index))) / ch_step_size, 0) * ch_step_size)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>actual_bin_index</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>int(func_current_bin_index[0]) if ((func_channel_signal_level_avg_unmuted or button_hold) and (int(math.floor(float(func_current_bin_index[0])/bin_floor)*bin_floor) not in blocked_bin_list) ) else int(new_bin_index)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_samp_rate</value></param>
<param><key>value</key><value>48e3*1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>quad_samp_rate</value></param>
<param><key>value</key><value>audio_samp_rate*4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gui_refresh_rate</value></param>
<param><key>value</key><value>2**2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>combined_ch_bins</value></param>
<param><key>value</key><value>int(float(channel_samp_rate)/bin_bw)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>int(float(samp_rate)/bin_bw)</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_ch_width</value></param>
<param><key>value</key><value>int(6.25e3)</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>ch_width</value></param>
<param><key>writeback</key><value>ch_width</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>mimo_balance</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-100</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>0,3,1,1</value></param>
<param><key>notebook</key><value>nb_controls,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rx1_amplitude</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1e3</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>0,4,1,1</value></param>
<param><key>notebook</key><value>nb_controls,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rx2_amplitude</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1e3</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>0,5,1,1</value></param>
<param><key>notebook</key><value>nb_controls,1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>click_tune_type</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Click-to-Tune Type</value></param>
<param><key>value</key><value>0</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>labels</key><value>["Rough","Fine"]</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_min_center_freq</value></param>
<param><key>value</key><value>118e6</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>min_center_freq</value></param>
<param><key>writeback</key><value>min_center_freq</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_max_center_freq</value></param>
<param><key>value</key><value>136e6</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>max_center_freq</value></param>
<param><key>writeback</key><value>max_center_freq</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_ch_trans</value></param>
<param><key>value</key><value>int(1e3)</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>ch_trans</value></param>
<param><key>writeback</key><value>ch_trans</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>static_txt_center_freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>center_freq</value></param>
<param><key>value</key><value>center_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,3,1,1</value></param>
<param><key>notebook</key><value>nb_controls,7</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_squelch_threshold</value></param>
<param><key>value</key><value>-20</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>squelch_threshold</value></param>
<param><key>writeback</key><value>squelch_threshold</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>(samp_rate/2)*1.25</value></param>
<param><key>min</key><value>-10e6</value></param>
<param><key>max</key><value>10e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,2,1,1</value></param>
<param><key>notebook</key><value>nb_controls,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>squelch_threshold</value></param>
<param><key>label</key><value>Squelch</value></param>
<param><key>value</key><value>cfg_squelch_threshold</value></param>
<param><key>min</key><value>-100</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>notebook</key><value>nb_controls,0</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>ch_step_size</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>cfg_ch_step_size</value></param>
<param><key>choices</key><value>[1,10,100,1e3, 2.5e3, 5e3, 6.25e3, 8.33e3, 12.5e3, 25e3, 50e3,100e3, 200e3]</value></param>
<param><key>labels</key><value>["1","10","100","1e3", "2.5e3", "5e3", "6.25e3", "8.33e3", "12.5e3", "25e3", "50e3","100e3", "200e3"]</value></param>
<param><key>type</key><value>drop_down</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>0,4,1,1</value></param>
<param><key>notebook</key><value>nb_controls,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ch_trans</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>min(cfg_ch_trans,int(quad_samp_rate*0.99))</value></param>
<param><key>min</key><value>int(1e3)</value></param>
<param><key>max</key><value>int(quad_samp_rate*0.99)</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>1,5,1,1</value></param>
<param><key>notebook</key><value>nb_controls,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ch_width</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>min(cfg_ch_width,((quad_samp_rate/2)*0.9))</value></param>
<param><key>min</key><value>int(1e3)</value></param>
<param><key>max</key><value>int((quad_samp_rate/2)*0.9)</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>1,4,1,1</value></param>
<param><key>notebook</key><value>nb_controls,0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>max_center_freq</value></param>
<param><key>label</key><value>Max Center Freq</value></param>
<param><key>value</key><value>cfg_max_center_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,2,1,1</value></param>
<param><key>notebook</key><value>nb_controls,1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>min_center_freq</value></param>
<param><key>label</key><value>Min Center Freq</value></param>
<param><key>value</key><value>cfg_min_center_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,1,1,1</value></param>
<param><key>notebook</key><value>nb_controls,1</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb_controls</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['Main','Spectrum Sense']</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>spectrum_sense_button</value></param>
<param><key>label</key><value>Spectrum Sense</value></param>
<param><key>value</key><value>0</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>labels</key><value>["Disabled","Enabled"]</value></param>
<param><key>type</key><value>button</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>notebook</key><value>nb_controls,1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_blocked_freq_list</value></param>
<param><key>value</key><value>""</value></param>
<param><key>type</key><value>string</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>blocked_freq_list</value></param>
<param><key>writeback</key><value>txt_blocked_freq_list</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>max_channel_freq</value></param>
<param><key>label</key><value>Locked On Freq (Hz)</value></param>
<param><key>value</key><value>(round(float(left_edge_freq+(bin_bw*bin_index))/ ch_step_size, 0) * ch_step_size)</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,1,1,2</value></param>
<param><key>notebook</key><value>nb_controls,1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>txt_blocked_freq_list</value></param>
<param><key>label</key><value>Blocked Freqs (Hz, Space Separated)</value></param>
<param><key>value</key><value>cfg_blocked_freq_list</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,1,50</value></param>
<param><key>notebook</key><value>nb_controls,1</value></param>
</block>
<block>
<key>analog_nbfm_rx</key>
<param><key>id</key><value>analog_nbfm_rx_0</value></param>
<param><key>audio_rate</key><value>int(audio_samp_rate)</value></param>
<param><key>quad_rate</key><value>int(quad_samp_rate)</value></param>
<param><key>tau</key><value>50e-6</value></param>
<param><key>max_dev</key><value>5e3</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_lo_offset</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>(samp_rate/2)*1.25</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>lo_offset</value></param>
<param><key>writeback</key><value>lo_offset</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>func_quad_avg_mag_sqrd_unmuted</value></param>
<param><key>value</key><value>False</value></param>
<param><key>block_id</key><value>probe_avg_mag_sqrd</value></param>
<param><key>function_name</key><value>unmuted</value></param>
<param><key>poll_rate</key><value>float(func_probe_rate)/1</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>center_freq_hop_button</value></param>
<param><key>label</key><value>Center Freq Hop</value></param>
<param><key>value</key><value>0</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>labels</key><value>["Disabled","Enabled"]</value></param>
<param><key>type</key><value>button</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>2,0,1,1</value></param>
<param><key>notebook</key><value>nb_controls,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>label</key><value>RX Gain</value></param>
<param><key>value</key><value>cfg_rx_gain</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>74</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
<param><key>notebook</key><value>nb_controls,0</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_channel_click_freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>cfg_center_freq</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>channel_click_freq</value></param>
<param><key>writeback</key><value>channel_click_freq</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_center_freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>433.5e6</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>center_freq</value></param>
<param><key>writeback</key><value>center_freq</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>volume</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>value</key><value>cfg_volume</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>10</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,3,1,1</value></param>
<param><key>notebook</key><value>nb_controls,0</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_modulation</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>modulation</value></param>
<param><key>writeback</key><value>modulation</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_rx_gain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>rx_gain</value></param>
<param><key>writeback</key><value>rx_gain</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>samp_rate</value></param>
<param><key>writeback</key><value>samp_rate</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>type=b200,master_clock_rate=30e6</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(center_freq, rf_freq=(center_freq + lo_offset),rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>m</key><value>combined_ch_bins</value></param>
<param><key>n</key><value>fft_len</value></param>
<param><key>offset</key><value>int(bin_index-(float(combined_ch_bins)/2))</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fft_len</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value></value></param>
<param><key>shift</key><value>True</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_len</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>modulation_selector_in_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>2</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>output_index</key><value>0 if (func_quad_avg_mag_sqrd_unmuted) else 1</value></param>
<param><key>vlen</key><value>fft_len</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_len</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0</value></param>
<param><key>vlen</key><value>fft_len</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>blocks_probe_signal_vx_fft</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fft_len</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_len</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>combined_ch_bins</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>combined_ch_bins</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>window</key><value></value></param>
<param><key>shift</key><value>True</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>quad_decim</value></param>
<param><key>taps</key><value>(firdes.complex_band_pass_2(1, channel_samp_rate, -ch_width, 1, ch_trans, 40, firdes.WIN_HAMMING, 6.76)) if (modulation == 2) else ((firdes.complex_band_pass_2(1, channel_samp_rate, -1, ch_width, ch_trans, 40, firdes.WIN_HAMMING, 6.76)) if (modulation == 3) else (firdes.low_pass_2(1, channel_samp_rate, ch_width, ch_trans, 40, firdes.WIN_HAMMING, 6.76)))</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>threshold</key><value>squelch_threshold</value></param>
<param><key>alpha</key><value>0.001</value></param>
<param><key>ramp</key><value>1</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>analog_am_demod_cf</key>
<param><key>id</key><value>analog_am_demod_cf_0</value></param>
<param><key>chan_rate</key><value>quad_samp_rate</value></param>
<param><key>audio_decim</key><value>audio_decim</value></param>
<param><key>audio_pass</key><value>12500</value></param>
<param><key>audio_stop</key><value>25000</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>analog_feedforward_agc_cc</key>
<param><key>id</key><value>analog_feedforward_agc_cc_0_0</value></param>
<param><key>num_samples</key><value>1024</value></param>
<param><key>reference</key><value>1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fft_signal_level</value></param>
<param><key>value</key><value>[0.0]*(fft_len)</value></param>
<param><key>block_id</key><value>blocks_probe_signal_vx_fft</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>float(func_probe_rate)/1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_volume</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>volume</value></param>
<param><key>writeback</key><value>volume</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>cfg_ch_step_size</value></param>
<param><key>value</key><value>6.25e3</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.scanoo</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>ch_step_size</value></param>
<param><key>writeback</key><value>ch_step_size</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1_0_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Rough Tune</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>float(center_freq)</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>gui_ref_level</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>gui_fft_size</value></param>
<param><key>fft_rate</key><value>gui_refresh_rate</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>gui_average</value></param>
<param><key>win</key><value>window.hamming</value></param>
<param><key>win_size</key><value>gui_sizes</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>nb_gfx,0</value></param>
<param><key>freqvar</key><value>txt_center_freq</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>func_center_freq</value></param>
<param><key>value</key><value>[min_center_freq]</value></param>
<param><key>block_id</key><value>probe_center_freq</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>float(func_probe_rate)/4</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>audio_decim</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>analog_feedforward_agc_cc</key>
<param><key>id</key><value>analog_feedforward_agc_cc_0</value></param>
<param><key>num_samples</key><value>1024</value></param>
<param><key>reference</key><value>1</value></param>
</block>
<block>
<key>analog_probe_avg_mag_sqrd_x</key>
<param><key>id</key><value>probe_avg_mag_sqrd</value></param>
<param><key>type</key><value>c</value></param>
<param><key>threshold</key><value>squelch_threshold</value></param>
<param><key>alpha</key><value>0.00001</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>samp_rate</key><value>int(audio_samp_rate*1)</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>float(volume)/10</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>vocoder_codec2_encode_sp</key>
<param><key>id</key><value>vocoder_codec2_encode_sp_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>mode</key><value>codec2.MODE_3200</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>vocoder_gsm_fr_encode_sp</key>
<param><key>id</key><value>vocoder_gsm_fr_encode_sp_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_float_to_short</key>
<param><key>id</key><value>blocks_float_to_short_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_1_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0.1</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>center_freq if (not center_freq_hop_button) else (min_center_freq if ((func_center_freq[0] &gt; max_center_freq) or (func_center_freq[0] &lt; min_center_freq)) else (func_center_freq[0] + center_freq_step)) if (not func_quad_avg_mag_sqrd_unmuted) else center_freq</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_1_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>probe_center_freq</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>value</key><value>cfg_samp_rate</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,5,1,2</value></param>
<param><key>notebook</key><value>nb_controls,0</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0_1_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(center_freq, rf_freq=(center_freq + lo_offset),rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>clock_source0</key><value>mimo</value></param>
<param><key>time_source0</key><value>mimo</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(center_freq, rf_freq=(center_freq + lo_offset),rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>txt_center_freq</value></param>
<param><key>label</key><value>Center Freq</value></param>
<param><key>value</key><value>5.5e6</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>nb_controls,0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>channel_click_freq</value></param>
<param><key>label</key><value>Click Freq</value></param>
<param><key>value</key><value>5.505e6</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
<param><key>notebook</key><value>nb_controls,0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_2</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0_1_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.3</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(center_freq, rf_freq=(center_freq + lo_offset),rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>ant0</key><value>RXA</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1_0_0_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Fine Tune</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>float(center_freq)</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>gui_ref_level</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>gui_fft_size</value></param>
<param><key>fft_rate</key><value>gui_refresh_rate</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>gui_average</value></param>
<param><key>win</key><value>window.hamming</value></param>
<param><key>win_size</key><value>gui_sizes</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>nb_gfx,1</value></param>
<param><key>freqvar</key><value>channel_click_freq</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>combined_ch_bins</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb_gfx</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>["FFT Rough Tune","FFT Fine Tune","FFT Zoom","Waterfall Rough Tune","Waterfall Fine Tune","Waterfall Zoom","Scope"]</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Zoom</value></param>
<param><key>samp_rate</key><value>quad_samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>True</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>win_size</key><value>gui_sizes</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>nb_gfx,6</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_NORM</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Zoom</value></param>
<param><key>samp_rate</key><value>quad_samp_rate</value></param>
<param><key>baseband_freq</key><value>max_channel_freq</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>-10</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>gui_fft_size</value></param>
<param><key>fft_rate</key><value>gui_refresh_rate</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>gui_average</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>gui_sizes</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>nb_gfx,2</value></param>
<param><key>freqvar</key><value>channel_click_freq</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>15</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/tmp/scanoo_audio.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>modulation</value></param>
<param><key>label</key><value>Modulation</value></param>
<param><key>value</key><value>cfg_modulation</value></param>
<param><key>choices</key><value>[0,1,2,3,4]</value></param>
<param><key>labels</key><value>["AM","FM","LSB","USB","CW"]</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>0,2,1,2</value></param>
<param><key>notebook</key><value>nb_controls,0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>audio_decim</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>modulation_selector_in</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>5</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>output_index</key><value>modulation</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>modulation_selector_out</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>5</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>input_index</key><value>modulation</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>affinity</key><value>1</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Waterfall Rough Tune</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>float(center_freq)</value></param>
<param><key>dynamic_range</key><value>50</value></param>
<param><key>ref_level</key><value>gui_ref_level</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>2**10</value></param>
<param><key>fft_rate</key><value>4</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.25</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>gui_sizes</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>nb_gfx,3</value></param>
<param><key>freqvar</key><value>txt_center_freq</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Waterfall Fine Tune</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>float(center_freq)</value></param>
<param><key>dynamic_range</key><value>50</value></param>
<param><key>ref_level</key><value>gui_ref_level</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>2**10</value></param>
<param><key>fft_rate</key><value>4</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.25</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>gui_sizes</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>nb_gfx,4</value></param>
<param><key>freqvar</key><value>channel_click_freq</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Waterfall Fine Tune</value></param>
<param><key>samp_rate</key><value>channel_samp_rate</value></param>
<param><key>baseband_freq</key><value>max_channel_freq</value></param>
<param><key>dynamic_range</key><value>50</value></param>
<param><key>ref_level</key><value>gui_ref_level</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>2**10</value></param>
<param><key>fft_rate</key><value>4</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.25</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>gui_sizes</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>notebook</key><value>nb_gfx,5</value></param>
<param><key>freqvar</key><value>channel_click_freq</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_1_1</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>audio_decim</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modulation_selector_in_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modulation_selector_in_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>modulation_selector_in_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>fft_filter_xxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_1</source_block_id><sink_block_id>wxgui_fftsink2_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_1</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_1</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0_0</source_block_id><sink_block_id>wxgui_fftsink2_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0</source_block_id><sink_block_id>analog_feedforward_agc_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>blocks_probe_signal_vx_fft</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modulation_selector_in</source_block_id><sink_block_id>analog_am_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>modulation_selector_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_nbfm_rx_0</source_block_id><sink_block_id>modulation_selector_out</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_feedforward_agc_cc_0</source_block_id><sink_block_id>modulation_selector_in</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modulation_selector_in</source_block_id><sink_block_id>analog_nbfm_rx_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_1</source_block_id><sink_block_id>wxgui_fftsink2_1_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_feedforward_agc_cc_0_0</source_block_id><sink_block_id>blocks_complex_to_real_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>analog_feedforward_agc_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modulation_selector_out</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0_0</source_block_id><sink_block_id>blocks_complex_to_real_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_1_0</source_block_id><sink_block_id>wxgui_fftsink2_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_1_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_1_0</source_block_id><sink_block_id>wxgui_fftsink2_1_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_1_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modulation_selector_in</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modulation_selector_in</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>modulation_selector_out</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_1</source_block_id><sink_block_id>modulation_selector_out</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_0</source_block_id><sink_block_id>wxgui_fftsink2_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_0</source_block_id><sink_block_id>wxgui_fftsink2_1_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_1_1</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_1_1</source_block_id><sink_block_id>wxgui_fftsink2_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_1_1</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_1_1</source_block_id><sink_block_id>wxgui_fftsink2_1_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0_0</source_block_id><sink_block_id>probe_avg_mag_sqrd</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_1_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0_0_0</source_block_id><sink_block_id>blocks_complex_to_real_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0</source_block_id><sink_block_id>vocoder_codec2_encode_sp_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0_0_1</source_block_id><sink_block_id>blocks_float_to_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_codec2_encode_sp_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vocoder_gsm_fr_encode_sp_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_short_0</source_block_id><sink_block_id>vocoder_gsm_fr_encode_sp_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_1_0_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>probe_center_freq</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_1_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_2</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0_0_1</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0_1_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0_0_0_0</source_block_id><sink_block_id>blocks_complex_to_real_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>modulation_selector_in</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0_0_0_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_1_1</source_block_id><sink_block_id>modulation_selector_out</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
</flow_graph>
